Commit message: change

File: car1/urdf/car1.urdf (robot description, URDF)
Before this commit: robot car1, 12 links, 11 joints
Joints:
- joint support2baselink: origin xyz=0.56525 0 0.05 rpy=0 0 0 -> xyz=0.64 0 0.05 rpy=0 0 0
